<?xml version="1.0"?>
<setupdb version="7">history
	<active>Active Setup</active>
	<history>History
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.0
			<timestamp>Nov 4 14:41:57 2024</timestamp>
			<uuid>{806ad21e-0e59-419d-8c00-6944ff25c4eb}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/fs/student/minhbui/grad/RISCV_RTL/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/fs/student/minhbui/grad/RISCV_RTL/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/fs/student/minhbui/simulation/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="explorer" roOrView="view" runningOrFinished="finished">ExplorerRun.0
			<timestamp>Nov 4 15:01:03 2024</timestamp>
			<uuid>{9997c48e-18fe-440d-be44-731ccb76dc13}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/fs/student/minhbui/grad/RISCV_RTL/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/fs/student/minhbui/grad/RISCV_RTL/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/fs/student/minhbui/simulation/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.1
			<timestamp>Nov 4 15:08:01 2024</timestamp>
			<uuid>{3e6a3c12-374f-4bf4-99e7-6cb565c6e397}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/fs/student/minhbui/grad/RISCV_RTL/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/fs/student/minhbui/grad/RISCV_RTL/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/fs/student/minhbui/simulation/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
		<historyentry assemblerOrExplorer="assembler" roOrView="view" runningOrFinished="finished">Interactive.2
			<timestamp>Nov 4 15:10:01 2024</timestamp>
			<uuid>{4e7e1d4d-1e08-4368-87a9-c76bb57c4743}</uuid>
			<locked>0</locked>
			<mode>Single Run, Sweeps and Corners</mode>
			<resultsname>/fs/student/minhbui/grad/RISCV_RTL/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME.rdb</resultsname>
			<simresults>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.rdb</simresults>
			<runlog>/fs/student/minhbui/grad/RISCV_RTL/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME.log</runlog>
			<runlogfile>$AXL_SETUPDB_DIR/results/maestro/$AXL_HISTORY_NAME.log</runlogfile>
			<psfdir>/fs/student/minhbui/simulation/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME</psfdir>
			<simdir>$AXL_PROJECT_DIR/RISCV_LIB/tb_SRAM_WRITE_CP/maestro/results/maestro/$AXL_HISTORY_NAME</simdir>
		</historyentry>
	</history>
</setupdb>
